# Keil uVision project Lx07_Proj.uvprojx, settings and files
target Lx07 (6220000::V6.22::ARMCLANG)
  device: ARMCM0P ARM
  pack: ARM.Cortex_DFP.1.1.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ESEL ELITTLE
  output: Lx07_Test +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: DEV_Z20K118M
  c include: ..\..\StdDriver\Inc;..\..\Platform\Core;..\..\Platform;..\..\Platform\Devices;..\..\Platform\Devices\Z20K118M\Inc;..\Sch\inc;..\src
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x1fffc000 size 0x4000
  memory RVCT10: RAM 0x20000000 size 0x4000
  scatter file: ..\..\Platform\Devices\Z20K118M\MakeRule\ARMC\Z20K118M_flash.scf
  link misc: --entry=Reset_Handler
  group Devices
    ../../Platform/Devices/Z20K118M/Startup/ARMC/: Z20K118M_startup.s
  group Drv
    ../../StdDriver/Src/: Z20K11xM_clock.c Z20K11xM_drv.c Z20K11xM_gpio.c Z20K11xM_sysctrl.c Z20K11xM_uart.c Z20K11xM_wdog.c Z20K11xM_i2c.c Z20K11xM_stim.c Z20K11xM_tim.c Z20K11xM_srmc.c Z20K11xM_can.c
  group Src
    ../src/: main.c wdog.c
